# Keil uVision project Car_Project.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Car_Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: main.c pwm.c pwm.h led.c led.h camera.c camera.h motor.c motor.h
    ./modules/: adc.c adc.h dac.c dac.h ftm.c ftm.h gpio.c gpio.h pit.c pit.h uart.c uart.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
